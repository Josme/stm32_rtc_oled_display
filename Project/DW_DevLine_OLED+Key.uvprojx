# Keil uVision project DW_DevLine_OLED+Key.uvprojx, settings and files
target Project_Resource (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DWM1000_Dev +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Driver;..\System;..\System\Core;..\System\Lib\inc;..\Driver\decadriver;..\APP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ../System/Core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
    ../System/: board.c delay.c sys.c usart.c
  group Lib
    ../System/Lib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group Driver
    ../Driver/: oled.c tim3.c adc.c rtc_ctrl.c
  group APP
    ../System/: main.c
    ../APP/: task_manage.c display_menu.c
